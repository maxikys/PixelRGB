# Keil uVision project Project.uvprojx, settings and files
target STM32F072 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: EVSE +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\CMSIS\Device\ST\STM32F0xx\Include;.\CMSIS\Device\ST\STM32F0xx\Source\Templates;.\CMSIS\Device\ST\STM32F0xx\Source\Templates\arm;.\User\src;.\User\inc;.\STM32F0xx_StdPeriph_Driver\src;.\STM32F0xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group StartUp
    ./CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group Code
    ./User/src/: gpio_driver.c Keyboard.c platform_delay.c pwm.c RingBuffer.c systick.c WDT.c clock.c Spi.c usart.c main.c crc_calc.c adc2.c EXTI.c tim.c
    ./User/inc/: entertype.h
  group STD
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_misc.c
